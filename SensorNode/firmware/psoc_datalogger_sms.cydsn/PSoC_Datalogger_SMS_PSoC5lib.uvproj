# Keil uVision project PSoC_Datalogger_SMS_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: PSoC_Datalogger_SMS_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h uart.c uart.h uart_PM.c uart_INT.c uart_BOOT.c uart_IntClock.c uart_IntClock.h isr_byte_rx.c isr_byte_rx.h modem_power_pin_aliases.h modem_power_pin.c modem_power_pin.h modem_voltage_pin_aliases.h modem_voltage_pin.c modem_voltage_pin.h ultrasonic_voltage_pin_aliases.h ultrasonic_voltage_pin.c ultrasonic_voltage_pin.h isr_byte_ultrasonic_rx.c isr_byte_ultrasonic_rx.h SleepTimer.c SleepTimer.h uart_tx_aliases.h uart_tx.c uart_tx.h emFile_1.h emFile_1_ConfigMMC_SPI.c emFile_1_MMC_HW_SPI.c emFile_1_PM.c emFile_1_SPI0.c emFile_1_SPI0.h emFile_1_SPI0_PM.c emFile_1_SPI0_INT.c emFile_1_SPI0_PVT.h emFile_1_mosi0_aliases.h emFile_1_mosi0.c emFile_1_mosi0.h emFile_1_Clock_1.c emFile_1_Clock_1.h emFile_1_miso0_aliases.h emFile_1_miso0.c emFile_1_miso0.h emFile_1_sclk0_aliases.h emFile_1_sclk0.c emFile_1_sclk0.h emFile_1_SPI0_CS_aliases.h emFile_1_SPI0_CS.c emFile_1_SPI0_CS.h NEOMOTE_1_UART_MOTE.c NEOMOTE_1_UART_MOTE.h NEOMOTE_1_UART_MOTE_PM.c NEOMOTE_1_UART_MOTE_INT.c NEOMOTE_1_UART_MOTE_BOOT.c NEOMOTE_1_isr_RX.c NEOMOTE_1_isr_RX.h NEOMOTE_1_RX_RTS_n_aliases.h NEOMOTE_1_RX_RTS_n.c NEOMOTE_1_RX_RTS_n.h NEOMOTE_1_RX_CTS_n_aliases.h NEOMOTE_1_RX_CTS_n.c NEOMOTE_1_RX_CTS_n.h NEOMOTE_1_TX_RTS_n_aliases.h NEOMOTE_1_TX_RTS_n.c NEOMOTE_1_TX_RTS_n.h NEOMOTE_1_TX_CTS_n_aliases.h NEOMOTE_1_TX_CTS_n.c NEOMOTE_1_TX_CTS_n.h NEOMOTE_1_isr_RX_RTSn.c NEOMOTE_1_isr_RX_RTSn.h NEOMOTE_1_External_VRef_aliases.h NEOMOTE_1_External_VRef.c NEOMOTE_1_External_VRef.h NEOMOTE_1_I2C_0.c NEOMOTE_1_I2C_0.h NEOMOTE_1_I2C_0_BOOT.c NEOMOTE_1_I2C_0_INT.c NEOMOTE_1_I2C_0_PM.c NEOMOTE_1_I2C_0_SLAVE.c NEOMOTE_1_I2C_0_MASTER.c NEOMOTE_1_I2C_0_PVT.h NEOMOTE_1_I2C_0_SDA_aliases.h NEOMOTE_1_I2C_0_SDA.c NEOMOTE_1_I2C_0_SDA.h NEOMOTE_1_I2C_0_SCL_aliases.h NEOMOTE_1_I2C_0_SCL.c NEOMOTE_1_I2C_0_SCL.h NEOMOTE_1_NEO_RTC_INT1_aliases.h NEOMOTE_1_NEO_RTC_INT1.c NEOMOTE_1_NEO_RTC_INT1.h NEOMOTE_1_isr_rtc_int1.c NEOMOTE_1_isr_rtc_int1.h NEOMOTE_1_SD_Card_Power_aliases.h NEOMOTE_1_SD_Card_Power.c NEOMOTE_1_SD_Card_Power.h NEOMOTE_1_UART_MOTE_IntClock.c NEOMOTE_1_UART_MOTE_IntClock.h uart_ultrasonic.c uart_ultrasonic.h uart_ultrasonic_PM.c uart_ultrasonic_INT.c uart_ultrasonic_BOOT.c uart_ultrasonic_IntClock.c uart_ultrasonic_IntClock.h uart_solinst.c uart_solinst.h uart_solinst_PM.c uart_solinst_INT.c uart_solinst_BOOT.c isr_solinst_byte_rx.c isr_solinst_byte_rx.h uart_solinst_tx_aliases.h uart_solinst_tx.c uart_solinst_tx.h solinst_power_pin_aliases.h solinst_power_pin.c solinst_power_pin.h uart_solinst_IntClock.c uart_solinst_IntClock.h isr_SleepTimer.c isr_SleepTimer.h NEOMOTE_1_RX_Pin_aliases.h NEOMOTE_1_RX_Pin.c NEOMOTE_1_RX_Pin.h NEOMOTE_1_TX_Pin_aliases.h NEOMOTE_1_TX_Pin.c NEOMOTE_1_TX_Pin.h NEOMOTE_1_TimeN_aliases.h NEOMOTE_1_TimeN.c NEOMOTE_1_TimeN.h NEOMOTE_1_RTC_Crystal_aliases.h NEOMOTE_1_RTC_Crystal.c NEOMOTE_1_RTC_Crystal.h NEOMOTE_1_RTC_Int2_aliases.h NEOMOTE_1_RTC_Int2.c NEOMOTE_1_RTC_Int2.h NEOMOTE_1_pwr_aliases.h NEOMOTE_1_pwr.c NEOMOTE_1_pwr.h NEOMOTE_1_pwr_1_aliases.h NEOMOTE_1_pwr_1.c NEOMOTE_1_pwr_1.h ControlReg_Modem.c ControlReg_Modem.h ControlReg_Solinst.c ControlReg_Solinst.h modem_reset_pin_aliases.h modem_reset_pin.c modem_reset_pin.h Vbat_aliases.h Vbat.c Vbat.h ADC_SAR_1.c ADC_SAR_1.h ADC_SAR_1_INT.c ADC_SAR_1_PM.c VBAT_EN_aliases.h VBAT_EN.c VBAT_EN.h ADC_SAR_1_IRQ.c ADC_SAR_1_IRQ.h ADC_SAR_1_theACLK.c ADC_SAR_1_theACLK.h ADC_SAR_1_Bypass_aliases.h ADC_SAR_1_Bypass.c ADC_SAR_1_Bypass.h SlowClock.c SlowClock.h Pin_Sampler_Completed_Sample_aliases.h Pin_Sampler_Completed_Sample.c Pin_Sampler_Completed_Sample.h isr_SampleCounter.c isr_SampleCounter.h Pin_Sampler_Sampler_Count_aliases.h Pin_Sampler_Sampler_Count.c Pin_Sampler_Sampler_Count.h BottleCount.c BottleCount.h Pin_Sampler_Power_aliases.h Pin_Sampler_Power.c Pin_Sampler_Power.h Pin_Sampler_Trigger_aliases.h Pin_Sampler_Trigger.c Pin_Sampler_Trigger.h SlowClock_1.c SlowClock_1.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: PSoC_Datalogger_SMS_PSoC5lib (library)
