# Keil uVision project Campbell_Conductivity_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Campbell_Conductivity_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h Clock_1.c Clock_1.h PWM_1.c PWM_1.h PWM_1_PM.c ADC_DelSig_1.c ADC_DelSig_1.h ADC_DelSig_1_PM.c ADC_DelSig_1_INT.c ADC_DelSig_1_theACLK.c ADC_DelSig_1_theACLK.h ADC_DelSig_1_Ext_CP_Clk.c ADC_DelSig_1_Ext_CP_Clk.h Sample_Hold_1.c Sample_Hold_1.h Sample_Hold_1_PM.c Sample_Hold_2.c Sample_Hold_2.h Sample_Hold_2_PM.c Sample_Hold_3.c Sample_Hold_3.h Sample_Hold_3_PM.c AMux_1.c AMux_1.h Cond_Vx_aliases.h Cond_Vx.c Cond_Vx.h Cond_Vs_aliases.h Cond_Vs.c Cond_Vs.h Temp_Vs_aliases.h Temp_Vs.c Temp_Vs.h Temp_Vx_aliases.h Temp_Vx.c Temp_Vx.h Cond_PWM_out_aliases.h Cond_PWM_out.c Cond_PWM_out.h Temp_Vout_aliases.h Temp_Vout.c Temp_Vout.h Cond_Vout_aliases.h Cond_Vout.c Cond_Vout.h Comp_1.c Comp_1.h Comp_1_PM.c Comp_2.c Comp_2.h Comp_2_PM.c Comp_3.c Comp_3.h Comp_3_PM.c PWM_2.c PWM_2.h PWM_2_PM.c
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: Campbell_Conductivity_PSoC5lib (library)
