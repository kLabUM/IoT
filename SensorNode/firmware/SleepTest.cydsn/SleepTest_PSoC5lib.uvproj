# Keil uVision project SleepTest_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: SleepTest_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h Pin_1_aliases.h Pin_1.c Pin_1.h Pin_2_aliases.h Pin_2.c Pin_2.h Pin_3_aliases.h Pin_3.c Pin_3.h Pin_4_aliases.h Pin_4.c Pin_4.h Pin_5_aliases.h Pin_5.c Pin_5.h Pin_6_aliases.h Pin_6.c Pin_6.h Pin_7_aliases.h Pin_7.c Pin_7.h Pin_8_aliases.h Pin_8.c Pin_8.h Pin_9_aliases.h Pin_9.c Pin_9.h Pin_15_aliases.h Pin_15.c Pin_15.h Pin_14_aliases.h Pin_14.c Pin_14.h inbt2_aliases.h inbt2.c inbt2.h crustal_aliases.h crustal.c crustal.h int1_aliases.h int1.c int1.h I2C_1.c I2C_1.h I2C_1_BOOT.c I2C_1_INT.c I2C_1_PM.c I2C_1_SLAVE.c I2C_1_MASTER.c I2C_1_PVT.h isr_1.c isr_1.h
target Release (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: as above
  output: SleepTest_PSoC5lib (library)
