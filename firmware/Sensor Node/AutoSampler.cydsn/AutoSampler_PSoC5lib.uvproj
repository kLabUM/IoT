# Keil uVision project AutoSampler_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: AutoSampler_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h Pin_Sampler_Power_aliases.h Pin_Sampler_Power.c Pin_Sampler_Power.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h Pin_Sampler_Trigger_aliases.h Pin_Sampler_Trigger.c Pin_Sampler_Trigger.h Pin_Sampler_Completed_Sample_aliases.h Pin_Sampler_Completed_Sample.c Pin_Sampler_Completed_Sample.h Pin_Sampler_Sampler_Count_aliases.h Pin_Sampler_Sampler_Count.c Pin_Sampler_Sampler_Count.h SlowClock.c SlowClock.h BottleCount.c BottleCount.h isr_SampleCounter.c isr_SampleCounter.h SlowClock_1.c SlowClock_1.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: AutoSampler_PSoC5lib (library)
