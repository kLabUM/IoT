# Keil uVision project Solinst Driver_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5588AXI-060ES1 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(80000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Solinst Driver_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h uart_solinst.c uart_solinst.h uart_solinst_PM.c uart_solinst_INT.c uart_solinst_BOOT.c isr_solinst_byte_rx.c isr_solinst_byte_rx.h uart_solinst_tx_aliases.h uart_solinst_tx.c uart_solinst_tx.h solinst_power_pin_aliases.h solinst_power_pin.c solinst_power_pin.h uart_solinst_IntClock.c uart_solinst_IntClock.h
target Release (ARM-GNU)
  device: CY8C5588AXI-060ES1 Cypress
  cpu: as above
  output: Solinst Driver_PSoC5lib (library)
