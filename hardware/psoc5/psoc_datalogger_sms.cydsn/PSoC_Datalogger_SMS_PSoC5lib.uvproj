# Keil uVision project PSoC_Datalogger_SMS_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: PSoC_Datalogger_SMS_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h uart.c uart.h uart_PM.c uart_INT.c uart_BOOT.c uart_IntClock.c uart_IntClock.h isr_byte_rx.c isr_byte_rx.h timer.c timer.h timer_PM.c isr_timer.c isr_timer.h modem_power_pin_aliases.h modem_power_pin.c modem_power_pin.h modem_voltage_pin_aliases.h modem_voltage_pin.c modem_voltage_pin.h ultrasonic_uart.c ultrasonic_uart.h ultrasonic_uart_PM.c ultrasonic_uart_INT.c ultrasonic_uart_BOOT.c ultrasonic_voltage_pin_aliases.h ultrasonic_voltage_pin.c ultrasonic_voltage_pin.h isr_byte_ultrasonic_rx.c isr_byte_ultrasonic_rx.h ultrasonic_uart_IntClock.c ultrasonic_uart_IntClock.h isr_1.c isr_1.h SleepTimer.c SleepTimer.h LED_Blue_aliases.h LED_Blue.c LED_Blue.h uart_tx_aliases.h uart_tx.c uart_tx.h uart_rx_voltage_pin_aliases.h uart_rx_voltage_pin.c uart_rx_voltage_pin.h uart_tx_voltage_pin_aliases.h uart_tx_voltage_pin.c uart_tx_voltage_pin.h
target Release (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: as above
  output: PSoC_Datalogger_SMS_PSoC5lib (library)
